# Keil uVision project FW_No_OS.uvproj, settings and files
target TC956X_PCIe_FW (ARM-ADS)
  device: Cortex-M3 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M3") ESEL ELITTLE
  output: TC956X_FW_NoOS
  AfterMake: fromelf --bin ./Obj/TC956X_FW_NoOS.axf -o ./Bin/TC956X_Firmware_PCIeBridge.bin
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\Src\Include;..\Firmware
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0xa000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group App
    ./Src/App/: main.c
    ./Src/: tc956x_intr.c
  group Startup
    ./Src/Startup/: tc956x_startup.s
  group Driver
    ./Src/: tc956x_gpio_driver.c tc956x_i2c_driver.c tc956x_uart_driver.c
